v {xschem version=3.4.7RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
